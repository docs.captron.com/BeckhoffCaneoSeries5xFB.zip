TYPE DisplayedNumber_Struct :
UNION
    num : UDINT;
    bytes : ARRAY[0..3] OF USINT;
END_UNION
END_TYPE
