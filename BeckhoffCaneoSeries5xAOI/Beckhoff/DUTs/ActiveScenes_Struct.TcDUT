TYPE ActiveScenes_Struct :
UNION
    num : INT;
    bytes : ARRAY[0..1] OF USINT;
END_UNION
END_TYPE
