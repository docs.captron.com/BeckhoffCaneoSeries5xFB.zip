TYPE StringToBytes :
UNION
    str   : STRING(5);       
    bytes : ARRAY[0..5] OF BYTE;  
END_UNION
END_TYPE
